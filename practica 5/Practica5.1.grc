options:
  parameters:
    author: estudiantes g2
    category: '[Modulos_J1A_g2]'
    copyright: UIS
    description: Modulado desarrollado para estudiar la envolvente compleja de una angular
    generate_options: hb
    id: EnvolventeComplejaPM
    output_language: python
    title: EnvolventeComplejaPM
  states: {}

blocks:
- name: Ac
  id: parameter
  parameters:
    label: Amplitud de portadora
    type: eng_float
    value: '100e-3'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: kp
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Ac
    type: complex
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: sin
    type: float
  states: {}
- name: blocks_transcendental_1
  id: blocks_transcendental
  parameters:
    name: cos
    type: float
  states: {}
- name: kp
  id: parameter
  parameters:
    label: Coeficiente de modulacion PM
    type: eng_float
    value: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_1, '0']
- [blocks_multiply_const_vxx_1, '0', pad_sink_0, '0']
- [blocks_transcendental_0, '0', blocks_float_to_complex_0, '1']
- [blocks_transcendental_1, '0', blocks_float_to_complex_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
