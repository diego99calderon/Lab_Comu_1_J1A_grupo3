options:
  parameters:
    author: J1A_G2
    copyright: UIS
    generate_options: qt_gui
    id: ModuladorAM
    output_language: python
    title: ModuladorAM
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '10e-3'
    stop: '4'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '10e-3'
    stop: '4'
    value: '100e-3'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: '50'
    step: '100e-3'
    stop: 2.2e3
    value: '50'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia tx
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Ka
    start: '0'
    step: '10e-3'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: ModuladorAm_J1A_g2_0
  id: ModuladorAm_J1A_g2
  parameters:
    Ac: Ac
    Ka: Ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: 20e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: calculoPotencia_0
  id: calculoPotencia
  parameters:
    l_vect: '1024'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc*1e6
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ModuladorAm_J1A_g2_0, '0', blocks_complex_to_mag_0, '0']
- [ModuladorAm_J1A_g2_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorAm_J1A_g2_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorAm_J1A_g2_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', ModuladorAm_J1A_g2_0, '0']
- [blocks_complex_to_mag_0, '0', calculoPotencia_0, '0']

metadata:
  file_format: 1
