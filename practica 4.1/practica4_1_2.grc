options:
  parameters:
    author: J1A Grupo2
    copyright: UIS
    generate_options: qt_gui
    id: TransmisorAm
    output_language: python
    title: Transmisor Am
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud Modulante
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '100e-3'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Ka
    start: '0'
    step: '100e-6'
    stop: '4'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: EnvolventeComplejaDSBSC_0
  id: EnvolventeComplejaDSBSC
  parameters:
    Ac: Ac
    k: Ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: calculoPotencia_0
  id: calculoPotencia
  parameters:
    l_vect: '1024'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [EnvolventeComplejaDSBSC_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', EnvolventeComplejaDSBSC_0, '0']
- [analog_sig_source_x_0, '0', calculoPotencia_0, '0']

metadata:
  file_format: 1
