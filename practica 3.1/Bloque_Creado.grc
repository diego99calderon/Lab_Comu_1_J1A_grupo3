options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: Bloque_Creado
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: Modulos_J1A_ParteEnteraJ1A_0
  id: Modulos_J1A_ParteEnteraJ1A
  parameters:
    PARAM1: 'True'
    PARAM2: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Modulos_J1A_ParteEnteraJ1A_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', Modulos_J1A_ParteEnteraJ1A_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
